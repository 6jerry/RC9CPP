# Keil uVision project RC9CPP_H723ZGT6.uvprojx, settings and files
target RC9CPP_H723ZGT6 (6210000::V6.21::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: RC9CPP_H723ZGT6 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=1
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM7,
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../RC9CPP_USER/H7_test;../RC9CPP_API/HARDWARE;../RC9CPP_API/MATH_LIB;../RC9CPP_API/HARDWARE/MOTOR;../RC9CPP_API/CONTROL;..\Drivers\CMSIS\DSP\Include;..\RC9CPP_API\CONTROL\STRUCTURE;..\RC9CPP_USER\RC2025\fast_debug;..\RC9CPP_API\DECISION
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: RC9CPP_H723ZGT6\RC9CPP_H723ZGT6.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c memorymap.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group RC9CPP_USER
    ../RC9CPP_USER/RC2025/fast_debug/: m3508_debug.cpp m3508_debug.h m3508_debug_setup.cpp m3508_debug_setup.h
  group RC9CPP_API
    ../RC9CPP_API/HARDWARE/: TaskManager.cpp TaskManager.h RC9Protocol.cpp RC9Protocol.h Serial_device.cpp Serial_device.h fdcan_device.cpp fdcan_device.h position.cpp position.h
    ../RC9CPP_API/MATH_LIB/: crc_util.c crc_util.h sort_search.c sort_search.h Vector2D.cpp Vector2D.h
    ../RC9CPP_API/HARDWARE/MOTOR/: M3508.cpp M3508.h motor.cpp motor.h vesc.cpp vesc.h
    ../RC9CPP_API/CONTROL/: PID.cpp PID.h SuperPID.cpp SuperPID.h TrapezoidalPlanner.cpp TrapezoidalPlanner.h filters.cpp filters.h debug_xbox.cpp debug_xbox.h xbox.cpp xbox.h
    ../RC9CPP_API/DECISION/: EncodingStateMachine.cpp EncodingStateMachine.h
  group DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7l_math.lib
software components: CMSIS:CORE 5.6.0
