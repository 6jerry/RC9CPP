# Keil uVision project m3508_test.uvprojx, settings and files
target m3508_test (6210000::V6.21::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: m3508_test +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/ARM/DSP/Inc;../RC9CPP_API;../RC9CPP_API/CONTROL;../RC9CPP_API/CONTROL/STRUCTURE;../RC9CPP_API/DECISION;../RC9CPP_API/HARDWARE;../RC9CPP_API/HARDWARE/MOTOR;../RC9CPP_API/MATH_LIB;../RC9CPP_USER;../RC9CPP_USER/R2N_USER;../RC9CPP_USER/structure_test;../RC9CPP_USER/R1N_USER;../RC9CPP_API/HARDWARE/NETWORK;G:/stm32_project_cpp/RC9CPP_H7/Drivers/CMSIS/DSP/Include;..\RC9CPP_USER\SHOOTER_CAR
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group RC9CPP_API
    ../RC9CPP_API/CONTROL/: PID.cpp PID.h xbox.cpp xbox.h TrapezoidalPlanner.cpp TrapezoidalPlanner.h SuperPID.cpp SuperPID.h LADRC.cpp LADRC.h pure_pursuit.cpp pure_pursuit.h
    ../RC9CPP_API/CONTROL/STRUCTURE/: chassis.cpp chassis.h
    ../RC9CPP_API/HARDWARE/: Action.h Acton.cpp can_device.cpp can_device.h RC9Protocol.cpp RC9Protocol.h Serial_device.cpp Serial_device.h TaskManager.cpp TaskManager.h
    ../RC9CPP_API/HARDWARE/MOTOR/: M3508.cpp M3508.h m6020.cpp m6020.h motor.cpp motor.h go1can.cpp go1can.h vesc.cpp vesc.h tb6612.cpp tb6612.h
    ../RC9CPP_API/MATH_LIB/: crc_util.c crc_util.h Vector2D.cpp Vector2D.h
    ../RC9CPP_API/DECISION/: EncodingStateMachine.cpp EncodingStateMachine.h
    ../RC9CPP_API/HARDWARE/NETWORK/: netswitch.cpp netswitch.h rcncore.cpp rcncore.h
  group RC9CPP_USER
    ../RC9CPP_USER/SHOOTER_CAR/: shootcar_setup.cpp shootcar_setup.h
    ../RC9CPP_USER/structure_test/: shoot_xbox.cpp shoot_xbox.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
